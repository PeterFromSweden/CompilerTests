<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\StrongLib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\WeakAndStrongLib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\WeakLib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\WeakOrStrong.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Debug</name>
            <member>
                <project>StrongLib</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>WeakAndStrongLib</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>WeakLib</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>WeakOrStrong</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
